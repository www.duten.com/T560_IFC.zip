Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-06-05T09:42:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 05 09:42:04 2019 * Host: SarahSams-HP * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{A4BB439D-A0CE-410F-84F5-6D809964CDC4}\ifc * Database version: 5507 * Database creation date: Wed Jun 05 09:42:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 05 09:42:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 05 09:42:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: Combination Unit Brushed Stainless Steel, Duten_PprTwlDpnsrs_T560:Combination Unit Brushed Stainless Steel:286370
In: Level 0
Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Combination Unit Stainless Steel; Manufacturer: Duten
Constraints - Elevation: 1200 mm; Host: <not associated>; Level: Level: Level 0; Default Elevation: 1200 mm
Dimensions - Area: 1.12705 m2; Volume: 0.0179366 m3
Other - Category: Generic Models; Family: Duten_PprTwlDpnsrs_T560: Combination Unit Brushed Stainless Steel; Family and Type: Duten_PprTwlDpnsrs_T560: Combination Unit Brushed Stainless Steel; Schedule Level: Level: Level 0; Type: Duten_PprTwlDpnsrs_T560: Combination Unit Brushed Stainless Steel; Type Id: Duten_PprTwlDpnsrs_T560: Combination Unit Brushed Stainless Steel; AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Moveable; BarCode: n/a; CodePerformance: CE; Color: Defined by Finish; Constituents: Stainless steel AISI 304; DurationUnit: Years; ExpectedLife: 5; Family Name: Duten_PprTwlDpnsrs_T560; Features: 25; Finish: Stainless steel AISI 304, Availabel in Brushed, Matte Black or White; Grade: n/a; InstallationDate: 1900-12-31T23:59:59; Material: Stainless Steel AISI 304; ModelNumber: T560-S; ModelReference: Combination Unit Stainless Steel; Name: PaperTowelDispensers_T560_Duten; ReplacementCost: 0; SerialNumber: n/a; Shape: Rectangular; Size: (H) 1360mm x (L) 125mm x (W) 380mm; SustainabilityPerformance: n/a; TagNumber: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: 25; WarrantyDurationParts: 25; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: contact@duten.fr; WarrantyGuarantorParts: contact@duten.fr; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
General - Author: Diane Butterworth Ltd; ManufacturerName: Duten; ManufacturerURL: http://www.duten.fr/; NBSDescription: Paper Towel Dispensers; NBSReference: 45-35-72/344; ProductInformation: https://www.duten.co.uk/products/recessed-units/entirely-concealed-combination-unit-t560; Revision: n/a; Uniclass2015Code: Pr-Products v1.10; Uniclass2015Title: Paper Towel Dispensers; Uniclass2015Version: Pr_40_70_22_62
Identity Data - Assembly Code: E2020200; Assembly Description: Furniture & Accessories; Cost: 0; Description: Combination Unit Stainless Steel; Keynote: Pr_40_70_22_62; Manufacturer: Duten; Model: T560-S; Type Comments: Combination Unit Stainless Steel; Type Name: Combination Unit Brushed Stainless Steel; URL: http://www.duten.fr/
